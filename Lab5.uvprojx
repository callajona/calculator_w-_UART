# Keil uVision project Lab5.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Lab5
  c flags: Optim=2 OneElfS=1 v6Lang=5 v6LangP=1 wLevel=3
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: main.c UART.c Init.h Buzzer.h calculate.h keypad.h LCD.h output.h PLL.h memory.h password.h password.c
    ../Calculator/: Buzzer.c Init.c calculate.c keypad.c LCD.c memory.c output.c PLL.c
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.1
